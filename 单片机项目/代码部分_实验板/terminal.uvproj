# Keil uVision project terminal.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: terminal +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: buzzer.c ds18b20.c key.c key_matrix.c lcd1602.c main.c onewire.c timer.c uart.c xpt2046.c
